<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Conversor_Audio\Conversor_Audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX01\EX01.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX02\EX02.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX03\EX03.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX04\EX04.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX05\EX05.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX06\EX06.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX07\EX07.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX08\EX08.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX09\EX09.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX10\EX10.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX11\EX11.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX12\EX12.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX13\EX13.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX15\EX15.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX16\EX16.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX17\EX17.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX18\EX18.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX19\EX19.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX20\EX20.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX21\EX21.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX21a\EX21A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX23\EX23.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX26\EX26.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EX_A\EX_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\P11\P11.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\P12\P12.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\P21\P21.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\P22\P22.ewp</path>
  </project>
  <batchBuild/>
</workspace>


